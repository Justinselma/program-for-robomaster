# Keil uVision project clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: clock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Documents
  asm include: ..\Documents
  group Source Group 1
    ./: STARTUP.A51 interrupt.c main.c plus.c check.c delayms.c display.c start.c time.c pwm.c
